<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\nucleo-f303k8-spi-dma-ssd1306.ewp</path>
  </project>
  <batchBuild />
</workspace>
